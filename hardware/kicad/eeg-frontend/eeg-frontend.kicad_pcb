# Repository Ishaka-M26/EEG-Platform

File README.md:

# EEG Platform

A custom multichannel EEG acquisition platform for exploring real-time EEG processing and closed-loop neurotechnology.

## Demo: Real-Time Blink Detection

The ADS1299 acquires data at 250 samples per second (SPS). The processor uses every 10th sample to calculate the peak-to-peak amplitude of Channel 1 over a 1-second window (25 samples).
When the peak-to-peak amplitude exceeds a threshold of 800 ADC counts, an LED is activated and held on for approximately 5 seconds.

In this test, a manually performed eye blink produced a transient
increase in the measured range and triggered the LED in real time.

<!-- video -->
https://github.com/user-attachments/assets/f996c3a0-e510-41c0-a689-779db01b0a72

### Electrode Placement
For the blink detection experiment, Channel 1 was configured to measure the differential voltage between Fp1 and A1, following the International 10–20 electrode placement system.
- CH1P (1P): Fp1, left frontopolar region
- CH1N (1N): A1, left earlobe (reference electrode)

The frontal electrode placement allows the system to capture voltage transients associated with eye blinks. These transients are primarily related to ocular activity (EOG artifacts) rather than cortical EEG activity.

<p align="center">
  <em>Electrode placement for blink detection based on the International 10–20 system.</em>
</p>

### Example output

```text
CH1 min=-23961 max=-23366 range=595  LED=0
CH1 min=-24158 max=-23965 range=193  LED=0
CH1 min=-24212 max=-22453 range=1759 LED=1  <-- blink detected
CH1 min=-24368 max=-24239 range=129  LED=1
CH1 min=-24333 max=-24226 range=107  LED=1
CH1 min=-24637 max=-24358 range=279  LED=1
```

The third window exceeded the detection threshold:
1759 > 800

and triggered the LED. The LED remains on for approximately 5 seconds
after detection, which is why LED=1 continues in the following
windows even though their ranges fall below the threshold.

## Experiment: Alpha-Band Spectral Analysis

As a next step toward real-time EEG-based brain-state estimation, I implemented FFT-based spectral analysis on the Zynq processing system.

EEG signals were recorded from an occipital channel under eyes-open (EO) and eyes-closed (EC) conditions. Power spectral density (PSD) was calculated using a 256-point Hann-windowed FFT at a sampling rate of 250 SPS.

### Preliminary Results

*Mean PSD under eyes-open and eyes-closed conditions. The shaded region indicates the alpha band (8–13 Hz).*

The preliminary results show differences in spectral power between the two conditions. However, a clear eyes-closed increase within the alpha band was not observed. Larger differences appeared at frequencies above 13 Hz.

Further validation of electrode contact, signal quality, and spectral characteristics is needed before attributing these differences to cortical alpha activity.

### Electrode Placement

For the alpha-band experiment, Channel 1 was configured to measure the differential voltage between the left occipital region and the left ear, based on the International 10–20 electrode placement system.
- CH1P (1P): Near O1, left occipital region
- CH1N (1N): A1, left ear (reference electrode)

Ten20 conductive paste was applied to improve electrode contact with the scalp.

<p align="center">
  <sub>Ten20 conductive paste used for electrode contact.</sub>
</p>

The occipital electrode placement was selected to investigate alpha-band activity (8–13 Hz), which is commonly more prominent over posterior brain regions during eyes-closed conditions.

## Setup

**Prototype setup: EEG electrodes, custom ADS1299 interface board, and Zybo Zynq-7000.**

**Hardware connections and major components of the current prototype.**

# Overview
A custom EEG acquisition platform for real-time neural signal measurement and future closed-loop neurostimulation research.

The system is built around a custom ADS1299-based EEG frontend and a Zynq-based processing platform.  
The current focus is reliable multichannel EEG acquisition, real-time data transfer, and system-level validation from analog input to digital processing.

---

## System Overview

The platform consists of:

- **Custom EEG Frontend Board**
  - ADS1299-based multichannel EEG acquisition
  - Input protection
  - On-board power regulation
  - BIAS / common-mode feedback
  - SPI interface to the processing platform

- **Zybo Z7 / Zynq Platform**
  - ADS1299 SPI interface
  - EEG data reception and transfer
  - Optional real-time processing
  - Future stimulation trigger generation

- **Host PC**
  - Visualization
  - Data logging
  - Offline analysis
  - System configuration

The long-term goal is to extend this platform toward a closed-loop architecture in which brain-state information is estimated in real time and used to control non-invasive stimulation.

---

## Custom EEG Frontend

The EEG frontend board is designed specifically for this project.

It is based on the **ADS1299**, an 8-channel, 24-bit analog front end for biopotential measurement.  
The board integrates EEG input protection, analog acquisition, power regulation, and the digital interface required for connection to the Zynq platform.

The KiCad schematic and PCB design files are available in:

```text
hardware/kicad/eeg-frontend/
```

## ADS1299 Initialization

The ADS1299 is configured directly from FPGA logic over SPI.
The initialization sequence was verified on hardware using Vivado ILA.

Vivado ILA capture of the ADS1299 initialization sequence. SPI chip-select, clock, and DIN activity are monitored in the PL, and config_done is asserted after the initialization sequence completes.

### Initialization sequence

| Step | SPI command | Purpose |
|---|---|---|
| 1 | `SDATAC (0x11)` | Stop continuous data mode before register writes |
| 2 | `WREG CONFIG3` | Enable internal reference |
| 3 | `WREG CH1SET..CH8SET` | Configure channel gain and input mode |
| 4 | `RDATAC (0x10)` | Resume continuous data output |

---

## Project Direction

The project is being developed in stages:

1. **EEG frontend design and fabrication**
2. **Multichannel EEG acquisition**
3. **Zynq-based real-time data handling**
4. **Signal processing and brain-state estimation**
5. **Future closed-loop stimulation integration**

The initial objective is not to build a complete clinical neurostimulation device, but to establish a reliable hardware and software platform for real-time EEG-based neural interface research.

---

## Repository Structure

```text
eeg-platform/
├── docs/
│   └── images/
│       ├── eeg-frontend-3d.png
│       ├── eeg-frontend-pcb.png
│       └── system_overview.png
│
├── hardware/
│   └── kicad/
│       ├── eeg-frontend/
│       └── reference_design/
│
└── README.md
```

## KiCad design hardware/kicad/eeg-frontend/eeg-frontend.kicad_pcb

Parts:
J1: EEG Connector; PinHeader_2x13_P2.54mm_Horizontal_mirror
J2: Conn_02x06_Top_Bottom; PinHeader_2x06_P2.54mm_Horizontal_pmod
J3: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J4: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical

Connections:
1N: J1.21; also elsewhere on the board
1P: J1.22; also elsewhere on the board
2N: J1.19; also elsewhere on the board
2P: J1.20; also elsewhere on the board
3N: J1.17; also elsewhere on the board
3P: J1.18; also elsewhere on the board
4N: J1.15; also elsewhere on the board
4P: J1.16; also elsewhere on the board
5N: J1.13; also elsewhere on the board
5P: J1.14; also elsewhere on the board
6N: J1.11; also elsewhere on the board
6P: J1.12; also elsewhere on the board
7N: J1.9; also elsewhere on the board
7P: J1.10; also elsewhere on the board
8N: J1.7; also elsewhere on the board
8P: J1.8; also elsewhere on the board
ADS_CLK_OUT: J3.6; also elsewhere on the board
AGND: J1.3, J1.4, J2.5, J2.11, J3.2, J4.1; also elsewhere on the board
AVDD: J1.1, J1.2; also elsewhere on the board
AVSS: J1.25, J1.26; also elsewhere on the board
BIAS: J1.5, J1.6; also elsewhere on the board
BIAS_INV: J4.2; also elsewhere on the board
DVDD: J3.1; also elsewhere on the board
PMOD_3V3: J2.6, J2.12; also elsewhere on the board
PMOD_CS: J2.4; also elsewhere on the board
PMOD_CS2: J2.10, J3.8; also elsewhere on the board
PMOD_DRDY: J2.7; also elsewhere on the board
PMOD_MISO: J2.3, J3.3; also elsewhere on the board
PMOD_MOSI: J2.2, J3.7; also elsewhere on the board
PMOD_RESET: J2.9, J3.5; also elsewhere on the board
PMOD_SCLK: J2.1, J3.4; also elsewhere on the board
PMOD_START: J2.8; also elsewhere on the board
SRB1: J1.24; also elsewhere on the board
SRB2: J1.23; also elsewhere on the board

Notes on the sheet:
Connect to ZYBO Z7 PMOD JC
DAISY BUS
EEG CONNECTOR

Parts:
C1, C2, C5, C7, C9, C10: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C20: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C11: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J5: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
Q1: DMP3099L; SOT-23
TP7: TP_AVSS; TestPoint_Pad_D2.0mm
TP8: TP_AVDD; TestPoint_Pad_D2.0mm
TP9: TP_DVDD; TestPoint_Pad_D2.0mm
TP10: TP_3V_ENABLE; TestPoint_Pad_D2.0mm
TP11: TP_VIN_SYS; TestPoint_Pad_D2.0mm
TP13: TP_VIN_BAT; TestPoint_Pad_D2.0mm
U3: LM2664M6/NOPB; SOT-23-6
U4: MCP1754T-3302E/OT; SOT-23-5
U5: TPS72325DBV; SOT-23-5
U6: TLV70025_SOT23-5; SOT-23-5

Connections:
3V ENABLE: TP10.1 (1_1), U4.3 (*SHDN)
-DVDD: C4.1, C5.1, U3.2 (OUT), U5.2 (IN), U5.3 (EN)
AGND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C20.2, C21.2, J5.2, Q1.1 (G), U3.1 (GND), U4.2 (GND), U5.1 (GND), U6.2 (GND); also elsewhere on the board
AVDD: C10.1, C11.1, TP8.1 (1_1), U6.5 (OUT); also elsewhere on the board
AVSS: C7.1, C8.1, TP7.1 (1_1), U5.5 (OUT); also elsewhere on the board
DVDD: C1.1, C9.1, TP9.1 (1_1), U3.4 (SD_N), U3.5 (V+), U4.5 (VOUT), U6.1 (IN), U6.3 (EN); also elsewhere on the board
unnamed: J5.1, Q1.3 (D)
unnamed: C3.1, U3.6 (CAP+)
unnamed: C3.2, U3.3 (CAP-)
unnamed: C6.1, U5.4 (NR)
PMOD_3V3: C20.1, C21.1, JP1.1 (A); also elsewhere on the board
VIN_BAT: JP1.3 (B), Q1.2 (S), TP13.1 (1_1)
VIN_SYS: C2.1, JP1.2 (C), TP11.1 (1_1), U4.1 (VIN)

Notes on the sheet:
PWR_FLAGはERCエラー (Input Power pin not driven by any Output Power pins) 対策
デカップリング用コンデンサ
ERCエラー(power input not driven)を回避するためCAP+とCAP-を Power Input属性からPassiveに変更(元々の属性の設定がおかしい)
VOLTAGE INVERTER
BATTERY
+2.5V REGULATOR
POWER SOURCE SELECT (BATTERY or PMOD 3V3)
-2.5V REGULATOR
ジャンパーで電源供給元を切り替えれるようにする。
OpenBCIのバッテリは LP503033(3.7V 500mA)
VIN_SYS -> +3V REGULATOR

Parts:
CN3, CN4, CN5, CN6, CN7: 1000pF; C_Array_Convex_4x0612
RN1, RN2, RN3, RN4, RN5: R_Array_4; R_Cat16-4
U2, U7, U8, U9, U10, U11: TPD4E1B06DCKR; SOT-363_SC-70-6

Connections:
1N: RN1.2 (R1), U8.4 (IO3); also elsewhere on the board
1P: RN1.4 (R2), U7.1 (IO1); also elsewhere on the board
2N: RN2.6 (R3), U8.2 (IO2); also elsewhere on the board
2P: RN2.8 (R4), U8.5 (IO4); also elsewhere on the board
3N: RN2.2 (R1), U9.4 (IO3); also elsewhere on the board
3P: RN2.4 (R2), U8.1 (IO1); also elsewhere on the board
4N: RN3.6 (R3), U9.2 (IO2); also elsewhere on the board
4P: RN3.8 (R4), U9.5 (IO4); also elsewhere on the board
5N: RN3.2 (R1), U10.4 (IO3); also elsewhere on the board
5P: RN3.4 (R2), U9.1 (IO1); also elsewhere on the board
6N: RN4.6 (R3), U10.2 (IO2); also elsewhere on the board
6P: RN4.8 (R4), U10.5 (IO4); also elsewhere on the board
7N: RN4.2 (R1), U11.4 (IO3); also elsewhere on the board
7P: RN4.4 (R2), U10.1 (IO1); also elsewhere on the board
8N: RN5.6 (R3), U11.2 (IO2); also elsewhere on the board
8P: RN5.8 (R4), U11.5 (IO4); also elsewhere on the board
AGND: CN3.1 (common), CN3.3 (common), CN3.5 (common), CN3.7 (common), CN4.1 (common), CN4.3 (common), CN4.5 (common), CN4.7 (common), CN5.1 (common), CN5.3 (common), CN5.5 (common), CN5.7 (common), CN6.1 (common), CN6.3 (common), CN6.5 (common), CN6.7 (common), CN7.1 (common), CN7.3 (common), CN7.4 (C2), CN7.5 (common), CN7.7 (common), RN5.3 (common), RN5.4 (R2), U2.1 (IO1), U2.3 (GND), U7.3 (GND), U8.3 (GND), U9.3 (GND), U10.3 (GND), U11.3 (GND); also elsewhere on the board
AVDD: U2.2 (IO2); also elsewhere on the board
AVSS: U7.4 (IO3); also elsewhere on the board
BIAS: RN5.2 (R1), U2.4 (IO3); also elsewhere on the board
BIAS_DRV: CN7.2 (C1), RN5.1 (common); also elsewhere on the board
IN1N: CN3.2 (C1), RN1.1 (common); also elsewhere on the board
IN1P: CN3.4 (C2), RN1.3 (common); also elsewhere on the board
IN2N: CN4.6 (C3), RN2.5 (common); also elsewhere on the board
IN2P: CN4.8 (C4), RN2.7 (common); also elsewhere on the board
IN3N: CN4.2 (C1), RN2.1 (common); also elsewhere on the board
IN3P: CN4.4 (C2), RN2.3 (common); also elsewhere on the board
IN4N: CN5.6 (C3), RN3.5 (common); also elsewhere on the board
IN4P: CN5.8 (C4), RN3.7 (common); also elsewhere on the board
IN5N: CN5.2 (C1), RN3.1 (common); also elsewhere on the board
IN5P: CN5.4 (C2), RN3.3 (common); also elsewhere on the board
IN6N: CN6.6 (C3), RN4.5 (common); also elsewhere on the board
IN6P: CN6.8 (C4), RN4.7 (common); also elsewhere on the board
IN7N: CN6.2 (C1), RN4.1 (common); also elsewhere on the board
IN7P: CN6.4 (C2), RN4.3 (common); also elsewhere on the board
IN8N: CN7.6 (C3), RN5.5 (common); also elsewhere on the board
IN8P: CN7.8 (C4), RN5.7 (common); also elsewhere on the board
SRB1: CN3.8 (C4), RN1.7 (common), RN1.8 (R4), U7.5 (IO4); also elsewhere on the board
SRB2: CN3.6 (C3), RN1.5 (common), RN1.6 (R3), U7.2 (IO2); also elsewhere on the board

Notes on the sheet:
ERCのエラー(Bidirectional and Power output are connected)のエラーがTPD4E1B06DCKRそれぞれに 起きていたが、意図的な接続なので、ERCの設定で該当Warningを除外するようにした。

Parts:
R9, R10, R11, R12, R13, R14, R15, R18: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP17: TP_SCLK; TestPoint_Loop_D2.50mm_Drill1.0mm
TP18: TP_MOSI; TestPoint_Loop_D2.50mm_Drill1.0mm
TP19: TP_CS; TestPoint_Loop_D2.50mm_Drill1.0mm
TP20: TP_START; TestPoint_Loop_D2.50mm_Drill1.0mm
TP21: TP_PWDN; TestPoint_Loop_D2.50mm_Drill1.0mm
TP22: TP_RESET; TestPoint_Loop_D2.50mm_Drill1.0mm
TP23: TP_DRDY; TestPoint_Loop_D2.50mm_Drill1.0mm
TP24: TP_MISO; TestPoint_Loop_D2.50mm_Drill1.0mm
TP25: TP_CS2; TestPoint_Loop_D2.50mm_Drill1.0mm

Connections:
ADS_CS: R10.2, TP19.1 (1_1); also elsewhere on the board
ADS_CS2: R12.2, TP25.1 (1_1)
ADS_DIN: R9.2, TP18.1 (1_1); also elsewhere on the board
ADS_DOUT: R14.2; also elsewhere on the board
ADS_DRDY: R15.2; also elsewhere on the board
ADS_PWDN: R16.2, TP21.1 (1_1); also elsewhere on the board
ADS_RESET: R13.2, R17.2, TP22.1 (1_1); also elsewhere on the board
ADS_SCLK: R18.2, TP17.1 (1_1); also elsewhere on the board
ADS_START: R11.2, TP20.1 (1_1); also elsewhere on the board
DVDD: R16.1, R17.1; also elsewhere on the board
PMOD_CS: R10.1; also elsewhere on the board
PMOD_CS2: R12.1; also elsewhere on the board
PMOD_DRDY: R15.1, TP23.1 (1_1); also elsewhere on the board
PMOD_MISO: R14.1, TP24.1 (1_1); also elsewhere on the board
PMOD_MOSI: R9.1; also elsewhere on the board
PMOD_RESET: R13.1; also elsewhere on the board
PMOD_SCLK: R18.1; also elsewhere on the board
PMOD_START: R11.1; also elsewhere on the board

Notes on the sheet:
PWDNもZynqから制御したかったけど、 限られたPMODピンからCS2を出したかったので、 PWDNはHi固定にすることにした。

Parts:
C12: 100uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C13, C14, C16, C17: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R1: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ADS1299; TQFP-64_10x10mm_P0.5mm

Connections:
ADS_CLK_OUT: U1.37 (CLK); also elsewhere on the board
ADS_CS: U1.39 (~CS); also elsewhere on the board
ADS_DIN: U1.34 (DIN); also elsewhere on the board
ADS_DOUT: U1.43 (DOUT); also elsewhere on the board
ADS_DRDY: U1.47 (~DRDY); also elsewhere on the board
ADS_PWDN: U1.35 (~PWDN); also elsewhere on the board
ADS_RESET: U1.36 (~RESET); also elsewhere on the board
ADS_SCLK: U1.40 (SCLK); also elsewhere on the board
ADS_START: U1.38 (START); also elsewhere on the board
AGND: U1.31 (RESV1), U1.33 (DGND), U1.41 (DAISY_IN), U1.49 (DGND), U1.51 (DGND), U1.60 (BIASREF), U1.64 (RESERVED); also elsewhere on the board
AVDD: U1.19 (AVDD), U1.21 (AVDD), U1.22 (AVDD), U1.54 (AVDD1), U1.56 (AVDD), U1.59 (AVDD); also elsewhere on the board
AVSS: C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, U1.20 (AVSS), U1.23 (AVSS), U1.25 (VREFN), U1.32 (AVSS), U1.53 (AVSS1), U1.57 (AVSS), U1.58 (AVSS); also elsewhere on the board
BIAS_DRV: C19.2, R1.2; also elsewhere on the board
BIAS_INV: U1.61 (BIASINV); also elsewhere on the board
DVDD: U1.48 (DVDD), U1.50 (DVDD), U1.52 (CLKSEL); also elsewhere on the board
IN1N: U1.15 (IN1N); also elsewhere on the board
IN1P: U1.16 (IN1P); also elsewhere on the board
IN2N: U1.13 (IN2N); also elsewhere on the board
IN2P: U1.14 (IN2P); also elsewhere on the board
IN3N: U1.11 (IN3N); also elsewhere on the board
IN3P: U1.12 (IN3P); also elsewhere on the board
IN4N: U1.9 (IN4N); also elsewhere on the board
IN4P: U1.10 (IN4P); also elsewhere on the board
IN5N: U1.7 (IN5N); also elsewhere on the board
IN5P: U1.8 (IN5P); also elsewhere on the board
IN6N: U1.5 (IN6N); also elsewhere on the board
IN6P: U1.6 (IN6P); also elsewhere on the board
IN7N: U1.3 (IN7N); also elsewhere on the board
IN7P: U1.4 (IN7P); also elsewhere on the board
IN8N: U1.1 (IN8N); also elsewhere on the board
IN8P: U1.2 (IN8P); also elsewhere on the board
unnamed: C19.1, R1.1, U1.62 (BIASIN), U1.63 (BIASOUT)
unnamed: C12.1, U1.28 (VCAP1)
unnamed: C16.1, U1.30 (VCAP2)
unnamed: C14.1, C15.1, U1.55 (VCAP3)
unnamed: C13.1, U1.26 (VCAP4)
unnamed: C17.1, C18.1, U1.24 (VREFP)
SRB1: U1.17 (SRB1); also elsewhere on the board
SRB2: U1.18 (SRB2); also elsewhere on the board

Notes on the sheet:
ADS1299のDVDDピンにてERC(Input Power pin not driven by any Output Power pins)のエラーが発生したので、その 回避のため、DVDDの元となっているMCP1754T-3302E/OTのVOUTを「Output」から「Power Output」に変更(元々がおかしいと思う)
RESERVED1(64pin)にGNDを直結させると、 Pins of type output and power output are connectedというERCエラー起きる。 (Pin64はoutput typeだからってのと関係してる) このエラー回避するため、シンボルのRESERVEDのtypeをOutputからPassiveに変更。
CLKSEL PIN=1, CONFIG1.CLK_EN BIT=1で動かす想定なので CLKはoutput pinとなる。これをDaisy側のADSにインプットする
デイジーはできるようにする方針のもと、DAISY_INはGNDに接続する。 これで問題ないと思う。OpenBCIもそうしているから。 ADS1299のデータシートにしたがってないやり方だが、以下の情報から、問題なさそう。 https://openbci.com/forum/index.php?p=/discussion/2617/daisy-clksel-question

Board: 4 copper layers, 60.0 x 67.3 mm, 75 parts (5 on the bottom side), 74 nets.
